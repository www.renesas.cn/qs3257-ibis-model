| I/O Buffer Information Specification (IBIS) Version 3.2 (August 20, 1999)
| IBIS is a standard for electronic behavioral specifications of integrated
| circuit input/output analog characteristics.
[IBIS Ver]   3.2
[File Name]   qs3257.ibs
[File Rev]   2.0
[Date]   August 12, 2005
[Notes]   IDT provides IBIS models as a service to our customers. You
   and your company shall not distribute, convey, sell or give
   these models to anyone else without receiving prior written
   permission from IDT. IDT reserves the right to make changes to
   its products or to discontinue any semiconductor product or
   service without notice, and advises its customers to obtain
   the latest version of relevant information to verify, before
   placing orders, that the information being relied on is
   current. Please be aware that your receipt and subsequent use
   of the IBIS information provided shall serve as acceptance of
   the terms and conditions of this agreement. If you do not
   accept these terms, you should return the IBIS model and any
   other accompanying information immediately.
[Disclaimer]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
[Copyright]   (C) Copyright 1999 Integrated Device Technology, Inc. All
   rights reserved. Unauthorized reproduction and/or distribution
   is strictly prohibited.
|History
|Rev 1.0 Created on October 27th 1999
|   2.0 Added Functional Group States  August 12 2005
|   Component QS3257
[Component]   QS3257
[Manufacturer]   Integrated Device Technology, Inc.
[Package]
| Package parasitics.  Uncomment one set.
| variable   typ   min   max
| QSOP
R_pkg   0.01   0.01   0.01
L_pkg   2.50nH   2.50nH   2.50nH
C_pkg   0.40pF   0.40pF   0.40pF
[Pin]   signal_name   model_name   R_pin   L_pin   C_pin
|1   S   ENABLE   NA   NA   NA
2   I0A   NC   NA   NA   NA
3   I1A   NC   NA   NA   NA
4   YA   NC   NA   NA   NA
5   I0B   NC   NA   NA   NA
6   I1B   NC   NA   NA   NA
7   YB   NC   NA   NA   NA
8   GND   GND   NA   NA   NA
9   YC   NC   NA   NA   NA
10   I1C   NC   NA   NA   NA
11   I0C   NC   NA   NA   NA
12   YD   NC   NA   NA   NA
13   I1D   NC   NA   NA   NA
14   I0D   NC   NA   NA   NA
|15   EB   ENABLE   NA   NA   NA
16   VCC   POWER   NA   NA   NA
[Series Pin Mapping]   pin_2   model_name   function_table_group
2   4   QSIO   A
3   4   QSIO   B
5   7   QSIO   C
6   7   QSIO   D
11   9   QSIO   E
10   9   QSIO   F
14   12   QSIO   G
13   12   QSIO   H
[Series Switch Groups]
|Function Group States
On A C F H /
On B D E G /
Off A B C D E F G H /
|   Series_MOSFET   This model type is for series switch
|   devices that can described by [On], [Off],
|   [R Series], [L Series], [Rl Series],
|   [C Series], [Lc Series], [Rc Series],
|   [Series Current] and [Series MOSFET]
|   keywords
[Model]   QSIO
Model_type   Series_switch
| variable   typ   min   max
| Silicon die-compacitance (excluding package cap)
| DeMux side (I0)
C_comp   5.15pF   4.74pF   5.34pF
| Mux side (Y)
|C_comp   7.06pF   6.90pF   7.18pF
[Temperature Range]   25.0   85   -40
[Voltage Range]   5.0V   4.75V   5.25V
[On]
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[Off]
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| Models and submodels in the file (1): QSIO (Series_switch)
